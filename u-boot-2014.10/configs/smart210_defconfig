## u-boot-2014.10/configs/smart210_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_SMART210=y
CONFIG_ARCH_S5PC1XX=y
CONFIG_DEFAULT_DEVICE_TREE="s5pc1xx-smart210"
```
